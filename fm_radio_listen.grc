options:
  parameters:
    generate_options: qt_gui
    id: Spectrograph
    output_language: python
    title: Spectrograph
  states: {}

blocks:
- name: audiogain
  id: variable_qtgui_range
  parameters:
    label: Audio Gain (dB)
    start: '0'
    step: '0.1'
    stop: '3'
    value: '1'
  states: {}
- name: bw
  id: variable_qtgui_range
  parameters:
    label: Bandwidth (kHz)
    start: '100'
    step: '50'
    stop: '3000'
    value: '2000'
  states: {}
- name: fcenter
  id: variable_qtgui_range
  parameters:
    label: Center frequency (MHz)
    start: '88'
    step: '0.025'
    stop: '1000'
    value: '915'
  states: {}
- name: rxgain
  id: variable_qtgui_range
  parameters:
    label: RX Gain (dB)
    start: '1'
    step: '0.1'
    stop: '60'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: samp_rate_k*bw*1e3
  states: {}
- name: samp_rate_k
  id: variable_qtgui_range
  parameters:
    label: Sampling rate multiplier
    rangeType: int
    start: '2'
    step: '1'
    stop: '10'
    value: '2'
    widget: counter
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '6'
    audio_pass: '20000'
    audio_stop: '25000'
    chan_rate: '350000'
    deviation: '75000'
    gain: audiogain
    tau: '75e-6'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    alias: Spectrum raw
    file: /home/earl/Desktop/AFRL SDR/AFRL code base/Observer/ADC_raw_FIFO
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    alias: Spectrum raw magnitude
    file: /home/santiago2/Desktop/AFRL SDR/AFRL code base/Observer/spectrum_raw_mag
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_1_0
  id: blocks_file_sink
  parameters:
    alias: Spectrum raw complex
    file: /home/santiago2/Desktop/AFRL SDR/AFRL code base/Observer/spectrum_raw_complex
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '128'
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '128'
    type: complex
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '128'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(128)
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    alias: Pluto
    bandwidth: int(bw*1e3)
    bbdc: 'True'
    buffer_size: int(samp_rate/10)
    filter_source: '''Auto'''
    frequency: int(fcenter*1e6)
    gain1: '''manual'''
    manual_gain1: rxgain
    quadrature: 'False'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    alias: Spectrograph
    bw: bw*1e3
    fc: fcenter
    fftsize: '512'
    grid: 'True'
    type: complex
    update_time: '0.001'
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    alias: USRP 2910 observer
    ant0: '"RX2"'
    bw0: bw*1E3
    center_freq0: fcenter*1E6
    gain0: rxgain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_fm_demod_cf_0, '0', audio_sink_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_file_sink_0_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_file_sink_0_1_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_mag_0, '0']
- [iio_pluto_source_0, '0', blocks_file_sink_0, '0']
- [iio_pluto_source_0, '0', blocks_stream_to_vector_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '0', analog_fm_demod_cf_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
